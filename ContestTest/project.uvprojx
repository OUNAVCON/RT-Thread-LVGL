# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, __FPU_PRESENT=1, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, DATA_SECTION_IS_CACHEABLE=1, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: applications;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\..\..\components\finsh;.;..\..\..\include;..\libraries\MIMXRT1060\CMSIS\Include;..\libraries\MIMXRT1060\MIMXRT1060;..\libraries\MIMXRT1060\MIMXRT1060\drivers;..\libraries\peripherals;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)--entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: cpuport.c context_rvds.S cpu_cache.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/ipc/: waitqueue.c workqueue.c dataqueue.c ringblk_buf.c ringbuffer.c pipe.c completion.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: dcd.c pin_mux.c clock_config.c
    board/: board.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: irq.c scheduler.c ipc.c thread.c idle.c kservice.c device.c timer.c mempool.c components.c object.c memheap.c clock.c
  group Libraries
    ../libraries/MIMXRT1060/MIMXRT1060/drivers/: fsl_lpuart.c fsl_xbara.c fsl_clock.c fsl_pxp.c fsl_common.c fsl_gpio.c fsl_cache.c fsl_xbarb.c
    ../libraries/MIMXRT1060/MIMXRT1060/: system_MIMXRT1062.c
    ../libraries/MIMXRT1060/MIMXRT1060/arm/: startup_MIMXRT1062.s
  group xip
    xip/: evkbmimxrt1060_flexspi_nor_config.c fsl_flexspi_nor_boot.c
